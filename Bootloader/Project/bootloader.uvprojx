# Keil uVision project bootloader.uvprojx, settings and files
target bootloader (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC123LD4AN0 Nuvoton
  pack: Nuvoton.NuMicro_DFP.1.3.12
  cpu: IRAM(0x20000000,0x5000) IROM(0x00000000,0x11000) CPUTYPE("Cortex-M0") CLOCK(12000000)
  output: bootloader +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\..\CMSIS\Include;..\..\Device\Nuvoton\NUC123\Include;..\..\StdDriver\inc;..\User
  memory RVCT4: ROM 0x0 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x5000
  link misc: --entry Reset_Handler
  group Startup
    ../../Device/Nuvoton/NUC123/Source/ARM/: startup_NUC123.s
  group Cmsis
    ../../Device/Nuvoton/NUC123/Source/: system_NUC123.c
  group Library
    ../../StdDriver/src/: fmc.c clk.c
  group User
    ../User/: main.c drv_flash.c
