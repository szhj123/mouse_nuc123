# Keil uVision project application.uvproj, settings and files
target application (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: NUC123LD4AN0 Nuvoton
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0-0x10FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: application +hex
  AfterMake: fromelf.exe --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: ..\..\CMSIS\Include;..\..\Device\Nuvoton\NUC123\Include;..\..\StdDriver\inc;..\User\App;..\User\Drv;..\User\Hal
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x11000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../../Device/Nuvoton/NUC123/Source/ARM/: startup_NUC123.s
  group Cmsis
    ../../Device/Nuvoton/NUC123/Source/: system_NUC123.c
  group Library
    ../../StdDriver/src/: clk.c gpio.c pdma.c
  group App
    ../User/App/: app_key.c main.c app_lcd.c app_light.c app_mouse_sensor.c app_mouse_protocol.c app_event.c app_usb.c app_calendar.c app_flash.c
  group Drv
    ../User/Drv/: drv_task.c drv_timer.c drv_lcd.c drv_light.c drv_usb.c drv_usb_descriptor.c drv_mouse_sensor.c drv_flash.c drv_event.c drv_calendar.c drv_key.c drv_spi_flash.c
  group Hal
    ../User/Hal/: hal_nuc123.c hal_interrupt.c hal_task.c hal_timer.c hal_spi_flash.c hal_lcd.c hal_light.c hal_usb.c hal_mouse_sensor.c hal_calendar.c hal_key.c
